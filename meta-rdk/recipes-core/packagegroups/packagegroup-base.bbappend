RDEPENDS_packagegroup-base-zeroconf = " packagegroup-base-usbhost \
    "

